# Keil uVision project stm32f429zi_disco_gcc.uvprojx, settings and files
target STM32F429ZI-DISCO (ARM-GNU)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ..\bin\fw.elf
  AfterMake: arm-none-eabi-size ..\bin\fw.elf
  group disco
    ../src/: board.c board_heap_table.h main.c
  group amos/kernel
    ../../../amos/kernel/core/: exception.c intrin.c intrin.h memory.c mutex.c queue.c startup.c threads.c
  group amos/hal
    ../../../amos/hal/stm32f4/: stm32f4xx.h irq.c systick.c mcu.c clock.c gpio.c emc.c dma.c lcdif.c spi.c i2c.c
    ../../../amos/kernel/hal/: irq-cm.c
  group amos/drivers
    ../../../amos/drivers/display/: ili9341.c
  group amos/utils
    ../../../amos/kernel/utils/: log.h properties.c properties.h string.c string.h
    ../../../amos/kernel/: types.h
